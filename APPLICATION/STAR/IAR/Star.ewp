# IAR project Star.ewp, settings and files
configuration STAR-NA-Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F5659 MSP430F5659
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: __STAR_5x; __DEBUG_MODE__
  ICC430.newCCIncludePaths: ; ..\; ..\..\..\DRV\; ..\..\..\COMMON\; ..\UIP\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk430f5659.xcl
  XLINK.XlinkStackSize: 1
configuration STAR-NA-Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: __STAR_5x
  ICC430.ADefines: NDEBUG
  group (top)
    ./: client.c dfu.c hal_enc.c main.c network.c
    ../UIP/: clock-arch.c dhcpc.c timer.c uip.c uip_arp.c
    ../../../DRV/: enc424j600.c flash.c SPI.c support.s43 timer_drv.c
    ../../../COMMON/: general.c
